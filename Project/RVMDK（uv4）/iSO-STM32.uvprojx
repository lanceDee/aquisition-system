# Keil uVision project iSO-STM32.uvprojx, settings and files
target uCOS_emWin (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 流水灯 +hex
  c flags: Optim=2 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\uC-CPU\ARM-Cortex-M3\RealView;..\..\uCOS-III\uC-LIB;..\..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\uCOS-III\uCOS-III\Source;..\..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\User\app;..\..\STemWinLibrary522\Config;..\..\STemWinLibrary522\inc;..\..\User\W5500;..\..\User\bsp\TimBase;..\..\User\ff9;..\..\User\sdcard;..\..\User\bsp\usart;..\..\User\bsp\I2C_EEPROM;..\..\User\bsp\spi_gpio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_i2c.c
  group USER
    ../../User/: main.c stm32f10x_it.c
  group uC/CPU
    ../../uCOS-III/uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm cpu_c.c
    ../../uCOS-III/uC-CPU/: cpu_core.c
  group uC/LIB
    ../../uCOS-III/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/Source
    ../../uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/Port
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.s os_cpu_c.c
  group BSP
    ../../User/bsp/: bsp.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/usart/: bsp_usart1.c
    ../../User/bsp/TimBase/: bsp_TiMbase.c
    ../../User/sdcard/: bsp_sdio_sdcard.c
    ../../User/bsp/I2C_EEPROM/: bsp_i2c_ee.c bsp_i2c_gpio.c
    ../../User/bsp/spi_gpio/: bsp_spi_gpio.c
  group os_cfg
    ../../User/app/: app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group app
    ../../User/app/: app.c
  group W5500
    ../../User/W5500/: socket.c utility.c w5500.c w5500_conf.c
  group ff9
    ../../User/ff9/option/: cc936.c
    ../../User/ff9/: diskio.c ff.c
  group DOC
    ../../Doc/: readme.txt
software components: CMSIS:CORE 4.1.0
